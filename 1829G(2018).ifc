Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-06-12T13:52:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20181011_1645(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 12 13:52:15 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{A4B95E47-615E-4E40-8315-3C40F89652D3}\ifc * Database version: 5507 * Database creation date: Wed Jun 12 13:52:14 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 12 13:52:14 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 12 13:52:14 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1829G Utility room faucet, 1829G(2018):1829G Utility room faucet:333281
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 253.754 mm; FaucetNominalHeight: 183.571 mm; FaucetNominalWidth: 54 mm; HandShowerNominalDepth: 88.8296 mm; HandShowerNominalHeight: 254.803 mm; HandShowerNominalWidth: 70.3783 mm; InletConnectionSize: 10 mm; Projection: 214 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1829G(2017); ConvergoRefNr: 0087-1906-0032-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 11/06/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: HC; Customs Code: 84818011; EAN Number: 6414150089572; EN Standard: EN 817; LVI Number: 6219150; Noise Class: I (ISO 3822)
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1829G; Catalog Drawing URL: http://static.oras.com/catdrw/1829G; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/1829G; FDV Document URL: http://www.oras.com/datasheet/1829G/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1829G; Group: Utility room faucets; Long Marketing: Utility room faucet with dishwasher valve and side brush. Swivel spout and aerator. Spout’s swing angle is factory preset at 120° (can be limited to 40°-80°). Lever is equipped with an eco-button for limiting flow-rate, which can be bypassed by pressing the button.; Manufacturer: Oras; Market: INT;FIN;EST;LTU;LVA;UKR; Model: 1829G Utility room faucet; Name_en: 1829G Utility room faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 590 x 290 x 65; Package Weight: 3.135 kg; Product Code: 1829G; Product Datasheet: http://www.oras.com/datasheet/1829G/en; Product Family: Oras Vega; Product Image URL: http://static.oras.com/image/1829G; Product URL: http://static.oras.com/1829G; Type Name: 1829G Utility room faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Connection Size: Ø10 mm; Eco Flow At 300kPa: 0.00247203 m3/s; Flow Rate At 300kPa: 0.00600349 m3/s; Installation and Maintenance: http://static.oras.com/manual/1829G; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 01ls: 105000 Pa; Spare Parts: http://static.oras.com/sp/1829G; Spout Type: Swivel spout
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Utility room; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1829G(2018); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1829G; Name: 1829G Utility room faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 55x255x185 mm / Hand shower: 70x90x255 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1829G; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1829G Utility room faucet
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.118118 m2; Volume: 0.00411334 m3
Identity Data - Mark: 7
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1829G(2018): 1829G Utility room faucet; Family and Type: 1829G(2018): 1829G Utility room faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1829G(2018): 1829G Utility room faucet; Type Id: 1829G(2018): 1829G Utility room faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
